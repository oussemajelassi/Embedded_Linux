SRC_URI += "file://001-adding-aht10.patch;subdir=git \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

